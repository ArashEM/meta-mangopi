RDEPENDS_${PN} += " nativesdk-xfel"
