PACKAGECONFIG_append = " kmsro lima"
